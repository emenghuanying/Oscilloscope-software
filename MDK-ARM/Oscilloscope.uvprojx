# Keil uVision project Oscilloscope.uvprojx, settings and files
target Oscilloscope (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Oscilloscope +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_HAL_DRIVER,STM32F429xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Oscilloscope\dev;..\Oscilloscope\osc;..\Oscilloscope\gui;..\Oscilloscope\fos;..\Oscilloscope\hzs;..\Oscilloscope\vc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __FS_*;--keep __FS_TSK_*
  group MDK-ARM
    ../Src/: system_stm32f4xx.c
    ./: startup_stm32f429xx.s
  group User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group hallib
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_sdram.c stm32f4xx_ll_dma2d.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c
  group fos
    ../Oscilloscope/fos/: fos.c fos_tsk.c
  group dev
    ../Oscilloscope/dev/: display_dev.c sdram.c middle.c led.c
  group osc
    ../Oscilloscope/osc/: osc.c osc_ui.c myiic.c osc_time.c
  group gui
    ../Oscilloscope/gui/: gui_dev.c gui_tsk.c win.c gui.c
software components: CMSIS:CORE 4.3.0
